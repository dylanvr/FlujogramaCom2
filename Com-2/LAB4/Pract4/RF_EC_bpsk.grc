options:
  parameters:
    author: radiogis_director
    generate_options: qt_gui
    id: fsk
    output_language: python
    title: fsk
  states: {}

blocks:
- name: Rb
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '128'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: 'Carrier Freq. '
    start: '0'
    step: samp_rate/1000
    stop: samp_rate/8
    value: Rb*4
  states: {}
- name: fd
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Deviation Freq
    start: '0'
    step: samp_rate/1000
    stop: samp_rate/8
    value: Rb
  states: {}
- name: h
  id: variable
  parameters:
    value: '[1]*Sps'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rb*Sps
  states: {}
- name: Menu
  id: qtgui_tab_widget
  parameters:
    gui_hint: 4,0,1,2
    label0: Message
    label1: Modulated-Time
    label2: Modulated-Freq
    label3: Constellatin
    num_tabs: '4'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2*math.pi*fd/(Rb*Sps)
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: math.pi
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport math\n\nclass blk(gr.sync_block):  \n    \"\"\"This block is a RF VCO and works as following: the first input is the amplitude and the second input is the phase \n    and the output is the modulated signal s(t) bandpass, it has two parameters: carrier frequency, and samp rate\"\"\"\n\n    def __init__(self, fc=128000, samp_rate=320000):  \n        gr.sync_block.__init__(\n            self,\n            name='e_RF_VCO_ff',   # block name \n            in_sig=[np.float32, np.float32], # float32 data type, the first input is the amplitude and second input is the phase  \n            out_sig=[np.float32] #floar32 data type, is modulated signtal s(t)\n        )\n        self.fc = fc #assing parameter fc \n        self.samp_rate = samp_rate #assing parameter samp_rate\n        self.n_m=0 \n\n    def work(self, input_items, output_items): #paramenter function \n        A=input_items[0] #amplitude input\n        Q=input_items[1] #phase input \n        y=output_items[0] #Base band signal output \n        N=len(A)# vector width (Amplitude)\n        n=np.linspace(self.n_m,self.n_m+N-1,N) #dicretize the vector \n        self.n_m += N\n        y[:]=A*np.cos(2*math.pi*self.fc*n/self.samp_rate+Q) #output bass band signal\n        return len(output_items[0])\n\n\n"
    fc: fc
    samp_rate: samp_rate
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import math

      class blk(gr.sync_block):  
          """This block is a CE VCO or baseband VCO and works as following: the first input is the amplitude, 
          while the second phase is the phase, the output is the complex envelope which has euler form """

          def __init__(self,):  
              gr.sync_block.__init__(
                  self,
                  name='e_CE_VCO_fc',  #block name  
                  in_sig=[np.float32, np.float32], # float32 data type, the first input is the amplitude and second input is the phase
                  out_sig=[np.complex64] # complex64 data type, output complex envelope.
              )
              
          def work(self, input_items, output_items): #paramenter function 
              A=input_items[0] #amplitude input
              Q=input_items[1] #phase input
              y=output_items[0] #output complex envelope.
              N=len(A)
              y[:]=A*np.exp(1j*Q) #output complex envelope, euler form.
              return len(output_items[0])
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self,):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='e_Acum',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.acum=0
              
          def work(self, input_items, output_items):
              x=input_items[0]
              y= output_items[0]


              y[:]=self.acum+np.cumsum(x)
              self.acum=y[-1]
              return len(y)
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: fff
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: Menu@3:3,1,1,1
    name: '"CE-Constellation"'
    size: '1024'
    type: complex
    width1: '8'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    gui_hint: Menu@2:2,1,1,1
    label1: RF Modulated Signal
    type: float
    width1: '2'
    ymax: '-35'
    ymin: '-65'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    gui_hint: Menu@2:3,1,1,1
    label1: CE-Modulated Signal
    type: complex
    width1: '2'
    ymax: '-35'
    ymin: '-65'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@0:3,1,1,1
    label1: p2
    marker1: '0'
    name: '"Message bipolar"'
    size: '16'
    srate: Rb
    stemplot: 'True'
    type: float
    width1: '3'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@0:4,1,1,1
    label1: p1
    name: Modudating Signal
    size: 16*Sps
    srate: samp_rate
    type: float
    width1: '3'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@1:2,1,1,1
    label1: Modulating Signal
    label2: RF Modulated signal
    name: Modulating versus RF Modulated Signal
    nconnections: '2'
    size: 16*Sps
    srate: samp_rate
    type: float
    width1: '4'
    width2: '2'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@1:3,1,1,1
    label1: I-Signal
    label2: Q-signal
    name: CE Modulated Signal
    size: 16*Sps
    srate: samp_rate
    type: complex
    width1: '2'
    width2: '2'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: p2
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: p3
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: p4
  states: {}
- name: virtual_sink_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: p4b
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: p2
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: p3
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: p4
  states: {}
- name: virtual_source_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: p4b
  states: {}

connections:
- [analog_const_source_x_0, '0', epy_block_0, '0']
- [analog_const_source_x_0, '0', epy_block_0_0, '0']
- [analog_random_source_x_0, '0', blocks_char_to_float_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_char_to_float_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_char_to_float_0, '0', virtual_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', virtual_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', epy_block_0, '1']
- [blocks_multiply_const_vxx_0_1, '0', epy_block_0_0, '1']
- [epy_block_0, '0', virtual_sink_0_0_0_0, '0']
- [epy_block_0_0, '0', virtual_sink_0_0_0_0_0, '0']
- [epy_block_0_1, '0', blocks_multiply_const_vxx_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [interp_fir_filter_xxx_0, '0', epy_block_0_1, '0']
- [interp_fir_filter_xxx_0, '0', virtual_sink_0_0_0, '0']
- [virtual_source_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_0_1, '0', qtgui_time_sink_x_0_1, '0']
- [virtual_source_0_1, '0', qtgui_time_sink_x_0_1_0, '0']
- [virtual_source_0_1_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_1_0, '0', qtgui_time_sink_x_0_1_0, '1']
- [virtual_source_0_1_0_0, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_0_1_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_0_1_0_0, '0', qtgui_time_sink_x_0_1_0_0, '0']

metadata:
  file_format: 1
